# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RCT6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F1
  c include: .\Start;.\User;.\Library;.\Library\inc;.\Library\src;.\System;.\Hardware;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable;.\FreeRTOS\source;.\FreeRTOS\portable\ARM_CM3;.\BSP_Board_Support_Package;.\DD_Device_Driver;.\HAL_Hardware_Driver_Layer;.\FSM;.\Motion_driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
  group FreeRTOS_Portable
    ./FreeRTOS/portable/: heap_4.c
    ./FreeRTOS/portable/ARM_CM3/: port.c portmacro.h
  group FreeRTOS_source
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FSM
    ./FSM/: event_bus.c event_bus.h fsm_core.c fsm_core.h fsm_key.c fsm_key.h fsm_main_system.c fsm_main_system.h fsm_motor.c fsm_motor.h sys_config.h sys_events.h fsm_sensor.c fsm_network.c fsm_network.h fsm_sensor.h
  group BSP
    ./BSP_Board_Support_Package/: bsp_servo.h bsp_led.c bsp_led.h bsp_oled.c bsp_oled.h bsp_servo.c bsp_debug_uart.c bsp_debug_uart.h bsp_mpu6050.c bsp_mpu6050.h bsp_esp8266.c bsp_esp8266.h bsp_sensor.c bsp_sensor.h
  group HAL
    ./HAL_Hardware_Driver_Layer/: hal_gpio.c hal_gpio.h hal_pwm.c hal_pwm.h hal_soft_i2c.h hal_soft_iic.c hal_delay.c hal_delay.h hal_uart.c hal_uart.h hal_hard_i2c.c hal_hard_i2c.h hal_exti.c hal_exti.h hal_uart_dma.c hal_uart_dma.h hal_adc_dma.c hal_adc_dma.h hal_tim_ic.c hal_tim_ic.h
  group DD
    ./DD_Device_Driver/: dev_led.c dev_led.h dev_servo.c dev_servo.h dev_ssd1306.c dev_ssd1306.h dev_ssd1306_font.h dev_mpu6050.c dev_mpu6050.h dev_dht11.c dev_dht11.h dev_mq2.c dev_mq2.h dev_hcsr04.c dev_hcsr04.h
  group Motion_dirver
    ./Motion_driver/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
